# IAR project udp_rtos_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE3 Milandr MDR1986VE3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARM_CM1; USE_MDR1986VE3; NDEBUG; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..; ..\periph\; ..\sys\; ..\ftp\; ..\tftp\; ..\http\; ..\proto\; ..\dhcp\; ..\utils\; ..\tasks\; ..\Library\FatFs; ..\Library\MDR32F9Qx_StdPeriph_Driver\inc; ..\Library\USB_Library; ..\Library\CMSIS\CM1\CoreSupport; ..\Library\CMSIS\CM1\DeviceSupport\MDR1986VE3\inc; ..\Library\CMSIS\CM1\DeviceSupport\MDR1986VE3\startup\iar; ..\Library\CMSIS\CM1\DeviceSupport\MDR1986VE3\startup; // если есть FreeRTOS; ..\Library\FreeRTOS\include\; ..\Library\FreeRTOS\MemMang; ..\Library\FreeRTOS\portable; // если есть lwip; ..\library\lwip\include\netif; ..\library\lwip\include\lwip; ..\library\lwip\include\ipv4; ..\library\lwip\include; ..\library\lwip\port\; ..\library\lwip\port\ethernetif
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\; ..\Library\FreeRTOS\Source\portable\IAR\ARM_CM0
  OBJCOPY.OOCOutputFile: udp_rtos_test.bin
  ILINK.IlinkOutputFile: udp_rtos_test.out
  ILINK.IlinkIcfFile: udp_rtos_test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../: main.c
  group Library/CMSIS
    ../library/CMSIS/CM1/DeviceSupport/MDR1986VE3/startup/iar/: startup_MDR1986VE3.s
  group Library/FreeRTOS/MemMang
    ../library/FreeRTOS/MemMang/: heap_2.c
  group Library/FreeRTOS/Portable
    ../library/FreeRTOS/portable/: port.c portasm.s
  group Library/FreeRTOS/src
    ../library/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Library/LwIP/core
    ../library/lwip/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Library/LwIP/core/api
    ../library/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Library/LwIP/core/ipv4
    ../library/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Library/LwIP/netif
    ../library/lwip/netif/: etharp.c loopif.c slipif.c
  group Library/LwIP/port/ethernetif
    ../library/lwip/port/ethernetif/: eth5_if.c eth_common.c sys_arch.c
  group Library/MDR32F9Qx_StdPeriph_Driver
    ../library/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_dsp.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_eth.c MDR32F9Qx_i2c.c MDR32F9Qx_led.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_sdio.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c
  group periph
    ../periph/: clock.c led.c systick.c uart1.c
  group sys
    ../sys/: MDR1986VE3_it.c system_MDR1986VE3.c
  group tasks
    ../tasks/: eth_task.c
  group utils
    ../utils/: crc16.c userfunc.c
